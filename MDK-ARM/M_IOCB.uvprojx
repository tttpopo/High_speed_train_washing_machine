# Keil uVision project M_IOCB.uvprojx, settings and files
target M_IOCB (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF)  CLOCK(8000000) CPUTYPE("Cortex-M3") TZ
  output: M_IOCB +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xE
  c include: ../Core/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;../my_drivers/easylogger/inc;../my_drivers/motor;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM3;../my_drivers/fal/inc;../my_drivers/FlashDB/inc;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../my_drivers/console;../my_drivers/ws2812;../my_drivers/Liquid_level;../my_drivers/Host_computer_protocol;../my_drivers/brush;../my_drivers/flowmeter;../my_drivers/battery
  asm include: ..\Core\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f103xe.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c freertos.c adc.c can.c dma.c rtc.c tim.c usart.c stm32f1xx_it.c stm32f1xx_hal_msp.c stm32f1xx_hal_timebase_tim.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_can.c stm32f1xx_hal_rtc.c stm32f1xx_hal_rtc_ex.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group elog
    ../my_drivers/easylogger/port/: elog_port.c
    ../my_drivers/easylogger/src/: elog.c elog_utils.c elog_buf.c
  group motor
    ../my_drivers/motor/: motor_drive.c motor_hal.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM3/: port.c
  group fal
    ../my_drivers/fal/src/: fal.c fal_flash.c fal_partition.c
    ../my_drivers/fal/porting/: fal_flash_port.c
  group fdb
    ../my_drivers/FlashDB/src/: fdb.c fdb_kvdb.c fdb_utils.c
  group console
    ../my_drivers/console/: console.c
  group rgb
    ../my_drivers/ws2812/: ws2812.c
  group liquid_level
    ../my_drivers/Liquid_level/: liquid_level.c
  group hcp
    ../my_drivers/Host_computer_protocol/: hcp.c
  group brush
    ../my_drivers/brush/: brush.c
  group flowmeter
    ../my_drivers/flowmeter/: flowmeter_hl.c
  group battery
    ../my_drivers/battery/: battery.c
software components: CMSIS:CORE 4.3.0
